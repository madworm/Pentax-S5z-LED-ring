# Repository madworm/Pentax-S5z-LED-ring

File README.md:

Pentax-S5z-LED-ring
===================

LAYOUT FILES: LED ring for my old Pentax S5z digital camera.

The center-hole diameter is 28mm and the board slides right over the extended objective.

You will find code for this project in [this](https://github.com/madworm/ATtiny_projects/tree/master/13/PT4115_PWM) repository.

---

Before having PC-boards made, please make sure you know about your manufacturer's peculiarities!
Especially drill-sizes and their tolerances may vary too much and give you trouble.

## KiCad design Pentax-S5z-LED-ring.kicad_pcb

Parts:
C1: 4.7µF
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED
IC1: ATTINY13-S; SO8-200
JP1: ISP
P1, P4: CONN_2
P2: +
P3: -
Q1: MOSFET_N
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 68R
R17: 150R
R18: 100k
R19, R20: 1k
SW1, SW2: SW_PUSH

Connections:
+5V: C1.1, IC1.10, JP1.2 (VTG), P1.1, P4.1
/MISO: IC1.7, JP1.1 (MISO), SW1.2
/PWM: IC1.6, JP1.4 (MOSI), R17.1
/RESET: IC1.1, JP1.5 (RST)
/SCK: IC1.9, JP1.3 (SCK), SW2.2
GND: C1.2, IC1.5, IC1.PAD, JP1.6 (GND), P1.2 (PM), Q1.2 (S), R18.2, R19.2, R20.2
unnamed: D1.1 (A), D2.1 (A), D3.1 (A), D4.1 (A), D5.1 (A), D6.1 (A), D7.1 (A), D8.1 (A), D9.1 (A), D10.1 (A), D11.1 (A), D12.1 (A), D13.1 (A), D14.1 (A), D15.1 (A), D16.1 (A), P2.1
unnamed: D1.2 (K), R1.1
unnamed: D2.2 (K), R2.1
unnamed: D3.2 (K), R3.1
unnamed: D4.2 (K), R4.1
unnamed: D5.2 (K), R5.1
unnamed: D6.2 (K), R6.1
unnamed: D7.2 (K), R7.1
unnamed: D8.2 (K), R8.1
unnamed: D9.2 (K), R9.1
unnamed: D10.2 (K), R10.1
unnamed: D11.2 (K), R11.1
unnamed: D12.2 (K), R12.1
unnamed: D13.2 (K), R13.1
unnamed: D14.2 (K), R14.1
unnamed: D15.2 (K), R15.1
unnamed: D16.2 (K), R16.1
unnamed: P3.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2
unnamed: P4.2 (PM), Q1.3 (D)
unnamed: Q1.1 (G), R17.2, R18.1
unnamed: R19.1, SW1.1
unnamed: R20.1, SW2.1

Notes on the sheet:
To power supply
To LED board
WW: 3.29V @ 26mA - 25mA --> 68R (5V) W: 3.19V @ 28mA - 25mA --> 68R (5V)

Board: 2 copper layers, 40.0 x 40.0 mm, 52 parts (6 on the bottom side), 28 nets.

Other parts of the board:
G1, G1.1: OSHW-logo_silkscreen_4mm
G2, G2.1: LED_smile_silkscreen_4mm
mouse-bite-2mm, mouse-bite-2mm#2: VAL**; MADW__mouse-bite-2mm-slot

## Commit log

2013-04-08 First doodles.
    Haven't decided yet how to drive the LEDs. Linear or switch-mode? Maybe
    with 2x AAA cells + boost converter + ATtiny13 for PWM control.
2013-04-08 Placed a few traces.
2013-04-08 Tweaks.
2013-04-08 Updated 'README.md
2013-04-08 Now I need a control board.
2013-04-09 Trying to build a controller board.
2013-04-09 Added proper SMD push-buttons.
2013-04-09 Note: add a capacitor.
2013-04-09 Getting there...
2013-04-10 Logos...
2013-04-10 Added 1k resistors for the pull-down switches. Just in case ;-)
2013-04-10 Had to redo the internal cutout. OSHPARK uses a 100mil router, not 0.8mm
2013-04-28 Changed the LED dropper resistors to 65R + added some text.
2013-04-29 68R it is.
2013-05-03 Moved vias away from the outside ring edge.
2013-05-03 Added a 'Docs' folder, put 2 small photos in there, updated README.md
2013-05-03 Changed the SOT23 footprint. Larger pads make it easier to solder.
2013-05-09 Updated the switch-footprint. Now included Mouser order number.
2013-05-14 Updated 'README.md'
2013-09-22 Minute tweaks.
2013-10-12 Added 3D modules for the PLCC2-3528 LEDs + silkscreen tweaks.
2013-12-13 Switched ATtiny13 to DFN10 package.
    Had to move to KiCAD's new way of handling footprint libraries.
2013-12-15 Shoved some traces around to stay clear of button switch bodies.
2013-12-18 Replaced ISP-header with a pogo-pin compatible one (1.27mm pin-spacing).
2013-12-19 Shoved some parts around. Should be a bit easier to assemble.
2013-12-31 Layout tweaks.
2014-12-03 Added some files to 'Docs'.
2015-04-10 Added link to code-repository to 'README.md'.
2015-04-10 Changed 0603 footprint for pull-down resistors (a bit larger).
